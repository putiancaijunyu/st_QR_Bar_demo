# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User; ..\..\uCOS-III\uC-CPU; ..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\IAR; ..\..\uCOS-III\uC-LIB; ..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\..\User\fonts; ..\..\emWin\Config; ..\..\emWin\GUI_X; ..\..\emWin\Include; ..\..\emWin\emWinTask
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c stm32f4xx_it.c
    ../../User/bsp_stm32f4xx/src/: bsp_eeprom_24xx.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_spi_bus.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin528_CM4_IAR_ot.a
  group GUI_X
    ../../emWin/GUI_X/: GUI_X.c
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_gt811.c bsp_ra8875_flash.c bsp_ra8875_port.c bsp_tft_lcd.c bsp_touch.c bsp_ts_ft5x06.c bsp_tsc2046.c LCD_ILI9488.c LCD_RA8875.c LCD_SPFD5420.c param.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../../User/: main.c
