# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\fonts;..\..\emWin\GUI_X;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\User\VSCREEN_MultiPage;..\..\Libraries\Barcode;..\..\Libraries\QRCreater;..\..\User\User_GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c bsp.h
    ../../User/bsp_stm32f4xx/src/: bsp_timer.c bsp_key.c bsp_led.c bsp_tim_pwm.c bsp_spi_bus.c bsp_i2c_gpio.c bsp_uart_fifo.c bsp_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c LCD_SPFD5420.c LCD_ILI9488.c bsp_ra8875_flash.c bsp_ra8875_port.c param.c bsp_tsc2046.c bsp_gt811.c bsp_ts_ft5x06.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h
    ../../User/VSCREEN_MultiPage/: About.c Calibration.c LogoBitmap.c Setup.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin528_CM4_Keil_ot.lib
  group Doc
    ../../Doc/: 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group User_GUI
    ../../User/User_GUI/: FramewinDLG_WatchFace.c FramewinDLG_Applist.c FramewinDLG_BarCode.c FramewinDLG_QRCode.c
  group QRCode
    ../../Libraries/QRCreater/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group BarCode
    ../../Libraries/Barcode/: BarCode.c
